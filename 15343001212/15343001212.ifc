Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-03-23T08:09:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 23 08:09:26 2022 * Host: DLI-L5jdgnbTSD7 * Database: C:\Users\gba\AppData\Local\Temp\873c5505-23e6-4800-9695-9ff902d9ad54\2b7c7509-35a3-4307-868d-a64d5d7d2ffa\ifc * Database version: 5507 * Database creation date: Wed Mar 23 08:09:22 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 23 08:09:22 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 23 08:09:22 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, First Floor
LongName: First Floor; Elevation: 0 ft
Pset_ProductRequirements - Name: First Floor; Category: Levels
Pset_AirSideSystemInformation - Name: First Floor

# IfcDoor: 15343001212:dline_Hardware_KnudHolscherCollection_PZ-EuroEscutcheon_Solid_CC38, 15343001212:dline_Hardware_KnudHolscherCollection_PZ-EuroEscutcheon_Solid_CC38:565535
In: First Floor
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: <Unnamed>
Type - Pset_ConcreteElementGeneral - FireRating: n/a
Type - Pset_DoorCommon - IsExternal: no; Reference: n/a; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no; FireRating: n/a; AcousticRating: n/a; SecurityRating: n/a
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@dline.com
Type - Pset_ProductRequirements - Name: dline_Hardware_KnudHolscherCollection_PZ-EuroEscutcheon_Solid_CC38; Category: Doors
Type - Pset_QuantityTakeOff - Reference: n/a
OverallHeight: 0.298699 ft; OverallWidth: 0.164042 ft
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_PrecastConcreteElementGeneral - SerialNumber: n/a

# IfcDoor: Single-Flush:36" x 84", Single-Flush:36" x 84":564436
In: First Floor
Type - OperationType: SINGLE_SWING_RIGHT; ParameterTakesPrecedence: no; Sizeable: no; Classification: C1020 Interior Doors (Uniformat); Material: Door - Frame (2), Door - Panel
Type - Single-Flush:36" x 84":564436:1 - PanelOperation: SWINGING
Type - Pset_DoorCommon - IsExternal: no
Type - Pset_ProductRequirements - Category: Doors
OverallHeight: 7.25 ft; OverallWidth: 3.5 ft
Pset_DoorCommon - Reference: 36" x 84"
Pset_QuantityTakeOff - Reference: 36" x 84"
